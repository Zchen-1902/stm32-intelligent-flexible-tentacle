# Keil uVision project VL53LXCH.uvprojx, settings and files
target VL53LXCH (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VL53LXCH +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\examples;..\VL53LMZ_ULD_API\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c platform.c printf.c vl53lx_test.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group VL53LMZ_ULD_API
    ../VL53LMZ_ULD_API/src/: vl53lmz_api.c vl53lmz_plugin_cnh.c vl53lmz_plugin_detection_thresholds.c vl53lmz_plugin_motion_indicator.c vl53lmz_plugin_xtalk.c
  group examples
    ../examples/: Example_1_ranging_basic.c Example_2_get_set_params.c Example_3_ranging_modes.c Example_4_power_modes.c Example_5_multiple_targets_per_zone.c Example_6_I2C_and_RAM_optimization.c Example_7_calibrate_xtalk.c Example_8_vizualize_xtalk_data.c Example_9_detection_thresholds.c Example_10_motion_indicator.c Example_11_motion_indicator_with_detection_thresholds.c Example_12_cnh_data.c Example_13_rtrobot_software.c
software components: CMSIS:CORE 6.1.0
