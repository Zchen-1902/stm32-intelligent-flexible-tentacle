# Keil uVision project H743VIT6.uvprojx, settings and files
target H743VIT6 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H743VIT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Core/act_stream;../Core/act_policy_app;../Core/vl53_app;../Core/vl53_platform;../Core/Vofa_debug;../Core/can_app;../Core/motor_control_app;../Core/w25q64_app;../VL53LXCH/VL53LMZ_ULD_API/inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../X-CUBE-AI/App;../X-CUBE-AI;../Middlewares/ST/AI/Inc;Middlewares/ST/AI/Inc;X-CUBE-AI/App
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: H743VIT6.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c fdcan.c i2c.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/VL53_App
    ../Core/Src/: csv_logger.c
    ../Core/vl53_app/: vl53_app.c
    ../Core/vl53_platform/: platform.c
  group Application/User/VOFA
    ../Core/Vofa_debug/: vofa.c
  group Application/User/ACT_Stream
    ../Core/act_stream/: act_stream.c act_stream.h
  group Application/User/ACT_Policy_App
    ../Core/act_policy_app/: act_policy_app.c act_policy_app.h
  group Application/User/CAN_App
    ../Core/can_app/: can_app.c
  group Application/User/Motor_Control
    ../Core/motor_control_app/: motor_control_app.c
  group Application/User/W25Q64_App
    ../Core/w25q64_app/: w25q64_app.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/VL53LMZ_ULD_API
    ../VL53LXCH/VL53LMZ_ULD_API/src/: vl53lmz_api.c vl53lmz_plugin_cnh.c vl53lmz_plugin_motion_indicator.c
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: gesture_openness.c gesture_openness_data.c gesture_openness_data_params.c act_policy.c act_policy_data.c act_policy_data_params.c app_x-cube-ai.c
  group Doc
    ../X-CUBE-AI/App/: gesture_openness_generate_report.txt act_policy_generate_report.txt
    X-CUBE-AI/App/: gesture_openness_generate_report.txt act_policy_generate_report.txt
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
    Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
software components: CMSIS:CORE 4.3.0
